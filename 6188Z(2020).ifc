Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-01T13:40:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 01 13:40:33 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{8F3222E0-3AB3-421E-9497-3CD557A71B11}\ifc * Database version: 5507 * Database creation date: Mon Mar 01 13:40:32 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 01 13:40:33 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 01 13:40:33 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6188Z Washbasin faucet, 3 V, Bluetooth, 6188Z(2020):6188Z Washbasin faucet, 3 V, Bluetooth:347005
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 214.5 mm; NominalHeight: 74.5 mm; NominalWidth: 74.5 mm; Projection: 175 mm
Type - Electrical - Battery: AA 1.5 V Lithium x 2; Electronic Parts: Autofocus sensor;Solenoid valve;Low battery indication; Operating Voltage: 3 V
Type - Electrical Engineering - Bluetooth: 4.x
Type - General - Author: BIMStone; BIMObjectName: 6188Z(2020); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 16/02/2021
Type - Green Building Properties - Backflow Prevention EN1717: AA; Customs Code: 84818019; EAN Number: 6414150097850; EMC Directive: 2014/53/EU; EN Standard: EN 15091; LVI Number: 6110340; NRF Number: 4203662; Protection Class: IP 55; RSK Number: 8430638; VVS Number: 704293204
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/6188Z; Catalog Drawing URL: http://static.oras.com/catdrw/6188Z; Class: Touchless;Battery-operated;Bluetooth®; Dimension Drawing URL: http://static.oras.com/dimdrw/6188Z; FDV Document URL: http://www.oras.com/datasheet/6188Z/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6188Z; Group: Washbasin faucets; Long Marketing: Touchless washbasin faucet for cold or pre-mixed water. Battery-operated 3 V. Spout length 175 mm. laminar flow. The faucet is equipped with litter filter, non-return valve, shut-off valve and with G1/2” external connection thread.; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 6188Z Washbasin faucet, 3 V, Bluetooth; Name_en: 6188Z Washbasin faucet, 3 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 115 x 55; Package Weight: 1.355 kg; Product Code: 6188Z; Product Datasheet: http://www.oras.com/datasheet/6188Z/en; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6188Z; Product URL: http://static.oras.com/6188Z; Technical DataSheet URL: http://www.oras.com/datasheet/6188Z/en; Type Name: 6188Z Washbasin faucet, 3 V, Bluetooth
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Adjustable settings (via bluetooth); Aerator: Pressure controlled aerator;Laminar;Burglarproof; Afterflow Period: 3120; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection Size: G1/2; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Installation and Maintenance: http://static.oras.com/manual/6188Z; Installation Type: Wall mounted; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 211800; Mechanical Parts: Non-return valve(s);Litter filter(s); Noise Class: I (ISO 3822) Oras lab.; Pressure Loss With Flow 01ls: 200000 Pa; Spare Parts: http://static.oras.com/sp/6188Z; Spout Type: Fixed spout
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6188Z(2020); Features: Touchless;Battery-operated;Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6188Z; Name: 6188Z Washbasin faucet, 3 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 75x215x75 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0389244 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; OutletAngle: 0 deg; Volume: 0.00120152 m3
Identity Data - Mark: 5
Mechanical - System Classification: Domestic Hot Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 6188Z(2020): 6188Z Washbasin faucet, 3 V, Bluetooth; Family and Type: 6188Z(2020): 6188Z Washbasin faucet, 3 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6188Z(2020): 6188Z Washbasin faucet, 3 V, Bluetooth; Type Id: 6188Z(2020): 6188Z Washbasin faucet, 3 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
